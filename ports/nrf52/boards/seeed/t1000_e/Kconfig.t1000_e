## ports/nrf52/boards/seeed/t1000_e/board.yml
```yaml
board:
  name: t1000_e
  full_name: Seeed SenseCAP T1000-E
  vendor: seeed
  socs:
    - name: nrf52840
```
